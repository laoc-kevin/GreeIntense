# Keil uVision project GreeIntense.uvproj, settings and files
target GreeIntense (ARM-ADS)
  device: LPC4078 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: GreeIntense +hex
  c flags: Optim=2 OneElfS=1 wLevel=1
  c define: CORE_M4,ARM_MATH_CM4, __CC_ARM
  c include: .\CMSIS\inc;.\ChipDriver\inc;.\uCOS\uC_BSP;.\uCOS\uC_BSP\OS\uCOS-III;.\uCOS\uC_CFG;.\uCOS\uC_CPU;.\uCOS\uC_CPU\ARM-Cortex-M4;.\uCOS\uC_LIB;.\uCOS\uCOS_III\Source;.\uCOS\uCOS_III\Ports;.\App;.\CANFestival\include;.\CANFestival\include\lpc;.\CANFestival\driver;.\SEGGER_RTT;.\SEGGER_RTT\RTT;.\FreeModbus\config;.\FreeModbus\driver;.\FreeModbus\master\functions;.\FreeModbus\master\rtu;.\FreeModbus\master\port;.\FreeModbus\slave\rtu;.\FreeModbus\slave\functions;.\FreeModbus\slave\port;.\Module;.\OOC;.\Device
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group startup
    ./startup/: startup_LPC407x_8x_177x_8x.s
  group CMSIS
    ./CMSIS/src/: system_LPC407x_8x_177x_8x.c
  group ChipDriver
    ./ChipDriver/src/: lpc_adc.c lpc_eeprom.c lpc_gpio.c lpc_pinsel.c lpc_pwm.c lpc_rtc.c lpc_timer.c lpc_uart.c lpc_wwdt.c debug_frmwrk.c lpc_nvic.c lpc_ssp.c lpc_clkpwr.c
  group App
    ./App/: app.c app_val.c
  group Device
    ./Device/: modularRoof.c device.c fan.c compressor.c animal.c animalTest.c sensor.c system.c
  group Module
    ./Module/: md_dtu.c md_input.c md_io.c md_led.c md_modbus.c md_output.c md_rtc.c md_segment.c md_watchdog.c md_event.c
  group uC_CPU
    ./uCOS/uC_CPU/ARM-Cortex-M4/: cpu_c.c cpu_a.asm
    ./uCOS/uC_CPU/: cpu_core.c
  group uC_LIB
    ./uCOS/uC_LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./uCOS/uC_LIB/Ports/: lib_mem_a.asm
  group uC_BSP
    ./uCOS/uC_BSP/: bsp.c bsp_int.c cpu_bsp.c
    ./uCOS/uC_BSP/OS/uCOS-III/: bsp_os.c
  group uC_CFG
    ./uCOS/uC_CFG/: os_app_hooks.c
  group uCOS_III
    ./uCOS/uCOS_III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./uCOS/uCOS_III/Ports/: os_cpu_a.asm os_cpu_c.c
  group SEGGER_RTT
    ./SEGGER_RTT/: my_rtt_printf.c
    ./SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MBMaster
    ./FreeModbus/master/functions/: mb_m.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c mbutils_m.c user_mb_dict_m.c user_mb_map_m.c user_mb_scan_m.c
    ./FreeModbus/master/rtu/: mbrtu_m.c
    ./FreeModbus/master/port/: mbporttimer_m.c mbportserial_m.c mbportevent_m.c
  group MBSlave
    ./FreeModbus/slave/functions/: mb.c mbfunccoils.c mbfunccpn.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c user_mb_dict.c user_mb_map.c
    ./FreeModbus/slave/cpn/: mbcpn.c
    ./FreeModbus/slave/rtu/: mbrtu.c
    ./FreeModbus/slave/port/: mbportevent.c mbportserial.c mbporttimer.c
  group MBDriver
    ./FreeModbus/driver/: lpc_mbdriver.c
